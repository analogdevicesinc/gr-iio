<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>attr_sink_example</value></param>
<param><key>author</key><value>Travis Collins</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>Attribute Sink Example</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>msg_source.msg_dic</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>iio_attr_sink</key>
<param><key>id</key><value>iio_attr_sink_0</value></param>
<param><key>channel</key><value>"voltage0"</value></param>
<param><key>device</key><value>"ad9361-phy"</value></param>
<param><key>uri</key><value>"ip:192.168.2.1"</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>msg_source</value></param>
<param><key>source_code</key><value>import pmt
key0 = pmt.intern("rf_bandwidth")
val0 = pmt.intern("23000000")
msg_dic = pmt.make_dict()
msg_dic = pmt.dict_add(msg_dic, key0, val0)</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>strobe</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>iio_attr_sink_0</sink_block_id><source_key>strobe</source_key><sink_key>attr</sink_key></connection>
</flow_graph>
