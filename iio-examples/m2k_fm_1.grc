<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>adc_samp_rate</value></param>
<param><key>value</key><value>100000000</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>gain_mode</value></param>
<param><key>value</key><value>"high"</value></param>
<param><key>false</key><value>"low"</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>true</key><value>"high"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>os_ratio</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>adc_samp_rate/os_ratio</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>uri</value></param>
<param><key>value</key><value>"ip:192.168.3.2"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_0</value></param>
<param><key>value</key><value>25000</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>samp_rate/2</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_0_0</value></param>
<param><key>value</key><value>100000000</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>PLL Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>80000000</value></param>
<param><key>step</key><value>10000</value></param>
<param><key>stop</key><value>500000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_1</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>volume</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.05</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>variable_qtgui_range_0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>1</value></param>
<param><key>quad_rate</key><value>250000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>variable_qtgui_range_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>2048</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import libm2k

import time

class blk(gr.basic_block):
   def __init__(self, uri='ip:192.168.2.1',):
       gr.basic_block.__init__(
           self,
           name='M2k Init',
           in_sig=None,
           out_sig=None
       )
       libm2k.m2kOpen(uri)
</value></param>
<param><key>uri</key><value>uri</value></param>
</block>
<block>
<key>iio_adf4350_sink</key>
<param><key>id</key><value>iio_adf4350_sink_0</value></param>
<param><key>anti_backlash_3ns_enable</key><value>0</value></param>
<param><key>aux_output_enable</key><value>0</value></param>
<param><key>aux_output_fundamental_enable</key><value>1</value></param>
<param><key>aux_output_power</key><value>0</value></param>
<param><key>band_select_clock_mode_high_enable</key><value>0</value></param>
<param><key>channel_spacing</key><value>10000</value></param>
<param><key>charge_cancellation_enable</key><value>0</value></param>
<param><key>charge_pump_current</key><value>2500</value></param>
<param><key>clk_divider_12bit</key><value>0</value></param>
<param><key>clk_divider_mode</key><value>0</value></param>
<param><key>clkin</key><value>10000000</value></param>
<param><key>cycle_slip_reduction_enable</key><value>0</value></param>
<param><key>lock_detect_function_integer_n_enable</key><value>0</value></param>
<param><key>lock_detect_precision_6ns_enable</key><value>0</value></param>
<param><key>low_spur_mode_enable</key><value>1</value></param>
<param><key>mute_till_lock_enable</key><value>0</value></param>
<param><key>muxout_select</key><value>1</value></param>
<param><key>output_power</key><value>1</value></param>
<param><key>phase_detector_polarity_positive_enable</key><value>1</value></param>
<param><key>power_up_frequency</key><value>100000000</value></param>
<param><key>reference_div2_enable</key><value>0</value></param>
<param><key>reference_div_factor</key><value>0</value></param>
<param><key>reference_doubler_enable</key><value>0</value></param>
<param><key>uri</key><value>uri</value></param>
</block>
<block>
<key>iio_attr_sink</key>
<param><key>id</key><value>iio_attr_sink_0</value></param>
<param><key>attr_type</key><value>0</value></param>
<param><key>channel</key><value>voltage0</value></param>
<param><key>device</key><value>m2k-fabric</value></param>
<param><key>output</key><value>False</value></param>
<param><key>required_enable</key><value>False</value></param>
<param><key>uri</key><value>uri</value></param>
</block>
<block>
<key>iio_attr_sink</key>
<param><key>id</key><value>iio_attr_sink_0_1</value></param>
<param><key>attr_type</key><value>1</value></param>
<param><key>channel</key><value>""</value></param>
<param><key>device</key><value>"m2k-adc"</value></param>
<param><key>required_enable</key><value>False</value></param>
<param><key>uri</key><value>uri</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>iio_attr_updater_0</value></param>
<param><key>attr</key><value>"gain"</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(gain_mode)</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>iio_attr_updater_0_1</value></param>
<param><key>attr</key><value>"sampling_frequency"</value></param>
<param><key>interval</key><value>0</value></param>
<param><key>value</key><value>str(adc_samp_rate)</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>iio_attr_updater_0_1_0</value></param>
<param><key>attr</key><value>"oversampling_ratio"</value></param>
<param><key>interval</key><value>0</value></param>
<param><key>value</key><value>str(os_ratio)</value></param>
</block>
<block>
<key>iio_attr_updater</key>
<param><key>id</key><value>iio_attr_updater_0_2</value></param>
<param><key>attr</key><value>"0"</value></param>
<param><key>interval</key><value>1000</value></param>
<param><key>value</key><value>str(variable_qtgui_range_0_0)</value></param>
</block>
<block>
<key>iio_device_source</key>
<param><key>id</key><value>iio_device_source_0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>channels</key><value>["voltage0", "voltage1"]</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>device</key><value>m2k-adc</value></param>
<param><key>uri</key><value>uri</value></param>
<param><key>device_phy</key><value>m2k-adc</value></param>
<param><key>params</key><value>[]</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>100000</value></param>
<param><key>decim</key><value>8</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>10000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>16382</value></param>
<param><key>gui_hint</key><value>9,0,2,1</value></param>
<param><key>name</key><value>"RAW-FFT"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>freqhalf</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>6,0,3,2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"LPF"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>9,1,2,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"RAW"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,0,4,2</value></param>
<param><key>name</key><value>"Waterfall"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>250</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_attr_updater_0</source_block_id><sink_block_id>iio_attr_sink_0</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>iio_attr_updater_0_1</source_block_id><sink_block_id>iio_attr_sink_0_1</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>iio_attr_updater_0_1_0</source_block_id><sink_block_id>iio_attr_sink_0_1</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>iio_attr_updater_0_2</source_block_id><sink_block_id>iio_adf4350_sink_0</sink_block_id><source_key>out</source_key><sink_key>attr</sink_key></connection>
<connection><source_block_id>iio_device_source_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_device_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
