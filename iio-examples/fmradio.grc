<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.8.git'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>2200000</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>8</value></param>
<param><key>quad_rate</key><value>384000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_device</value></param>
<param><key>label</key><value>Audio device</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"dmix:CARD=monitor,DEV=0"</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>device_name</key><value>audio_device</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decimation</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fm_station</value></param>
<param><key>label</key><value>FM station</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>93300000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hostname</value></param>
<param><key>label</key><value>Hostname</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>127.0.0.1</value></param>
</block>
<block>
<key>iio_fmcomms2_source</key>
<param><key>id</key><value>iio_fmcomms2_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x20000</value></param>
<param><key>ch1_en</key><value>True</value></param>
<param><key>ch2_en</key><value>True</value></param>
<param><key>ch3_en</key><value>False</value></param>
<param><key>ch4_en</key><value>False</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>gain1</key><value>"slow_attack"</value></param>
<param><key>gain2</key><value>"slow_attack"</value></param>
<param><key>uri</key><value>uri</value></param>
<param><key>frequency</key><value>fm_station</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>rf_port_select</key><value>"A_BALANCED"</value></param>
<param><key>bandwidth</key><value>20000000</value></param>
<param><key>samplerate</key><value>sample_rate</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>44100</value></param>
<param><key>decim</key><value>sample_rate / (384000 * decimation)</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>sample_rate / decimation</value></param>
<param><key>width</key><value>44100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>uri</value></param>
<param><key>label</key><value>URI</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'ip:analog.local'</value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_fmcomms2_source_0</source_block_id><sink_block_id>blocks_short_to_float_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
