<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>iio_adrv9009_zu11eg_source</key>
<param><key>id</key><value>iio_adrv9009_zu11eg_source_0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>gain1</key><value>"manual"</value></param>
<param><key>gain2</key><value>"manual"</value></param>
<param><key>uri</key><value>ip:analog</value></param>
<param><key>frequency1</key><value>2400000000</value></param>
<param><key>frequency2</key><value>2400000000</value></param>
<param><key>manual_gain1</key><value>64.0</value></param>
<param><key>manual_gain2</key><value>64.0</value></param>
<param><key>manual_gain3</key><value>64.0</value></param>
<param><key>manual_gain4</key><value>64.0</value></param>
<param><key>profile</key><value>""</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rx1_en</key><value>True</value></param>
<param><key>rx2_en</key><value>True</value></param>
<param><key>rx3_en</key><value>True</value></param>
<param><key>rx4_en</key><value>True</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label2</key><value></value></param>
<param><key>label3</key><value></value></param>
<param><key>label4</key><value></value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>iio_adrv9009_zu11eg_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_adrv9009_zu11eg_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iio_adrv9009_zu11eg_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>iio_adrv9009_zu11eg_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
</flow_graph>
