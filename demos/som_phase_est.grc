<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vlen</value></param>
<param><key>value</key><value>2**11</value></param>
</block>
<block>
<key>PhaseEstimator</key>
<param><key>id</key><value>PhaseEstimator_0</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/work/grcon/gr-iio/demos/chan1.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/work/grcon/gr-iio/demos/chan2.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>10</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>10</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>vlen</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/1024.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0_0</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1.0/1024.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>iio_adrv9009_zu11eg_source</key>
<param><key>id</key><value>iio_adrv9009_zu11eg_source_0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>gain1</key><value>"manual"</value></param>
<param><key>gain2</key><value>"manual"</value></param>
<param><key>uri</key><value>ip:192.168.86.24</value></param>
<param><key>frequency1</key><value>2400000000</value></param>
<param><key>frequency2</key><value>2400000000</value></param>
<param><key>manual_gain1</key><value>64.0</value></param>
<param><key>manual_gain2</key><value>64.0</value></param>
<param><key>manual_gain3</key><value>64.0</value></param>
<param><key>manual_gain4</key><value>64.0</value></param>
<param><key>profile</key><value></value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rx1_en</key><value>True</value></param>
<param><key>rx2_en</key><value>True</value></param>
<param><key>rx3_en</key><value>True</value></param>
<param><key>rx4_en</key><value>True</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui_tab_widget_0</value></param>
<param><key>label0</key><value>Correlation</value></param>
<param><key>label1</key><value>Sample Offset</value></param>
<param><key>label2</key><value>Phase</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Phase Error"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Degrees</value></param>
<param><key>ymax</key><value>180</value></param>
<param><key>ymin</key><value>-180</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Offset"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Sample Offset</value></param>
<param><key>ymax</key><value>20</value></param>
<param><key>ymin</key><value>-20</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>vlen</value></param>
<param><key>x_axis_label</key><value>"Sample Offset"</value></param>
<param><key>x_start</key><value>-vlen/2</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>6000</value></param>
<param><key>ymin</key><value>-10</value></param>
<param><key>y_axis_label</key><value>"Correlation Magnitude"</value></param>
</block>
<connection><source_block_id>PhaseEstimator_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PhaseEstimator_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>PhaseEstimator_0</source_block_id><sink_block_id>blocks_moving_average_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_adrv9009_zu11eg_source_0</source_block_id><sink_block_id>PhaseEstimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_adrv9009_zu11eg_source_0</source_block_id><sink_block_id>PhaseEstimator_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>iio_adrv9009_zu11eg_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iio_adrv9009_zu11eg_source_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
</flow_graph>
